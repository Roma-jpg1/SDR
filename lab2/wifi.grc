options:
  parameters:
    generate_options: qt_gui
    id: wifi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '2400000000'
    step: '1000000'
    stop: '2480000000'
    value: '2400000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(variable_qtgui_range_0)
    gain1: '''slow_attack'''
    quadrature: 'False'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.3.1
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '2462000000'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
